# Repository anton-vinogradov/esp32-leshy2 (continued)

## KiCad design hardware/ecad/kicad/LESHY2-RF-R2/LESHY2-RF-R2.kicad_pcb (continued)

Schematic: RF_21_BROADCAST_AIRBAND_RX.kicad_sch, Leshy2 R2 — FM/AM/SW/LW and mandatory receive-only 118-137-…

Parts:
C155, C158: GCM1555C1H121FA16D; C_0402_1005Metric
C156, C159: GJM1555C1H1R4WB01D; C_0402_1005Metric
C157, C160: GCM1555C1H200FA16D; C_0402_1005Metric
C161: GJM1555C1H5R7WB01D; C_0402_1005Metric
C162: CC0402BRNPO9BN2R8; C_0402_1005Metric
C163: GJM1555C1H5R8WB01D; C_0402_1005Metric
C164, C165, C168, C169, C175, C180, C181, C185: Murata GRM1555C1H102JA01D; C_0402_1005Metric
C166, C171, C174, C177, C178: Samsung CL05A105KA5NQNC; C_0402_1005Metric
C167, C172, C176, C179, C186, C187, C190, C191: Yageo CC0402KRX7R9BB104; C_0402_1005Metric
C170: GJM1555C1H4R7BB01D; C_0402_1005Metric
C173: Murata GJM1555C1H150JB01D; C_0402_1005Metric
C182: Murata GRM155R71A474KE01D; C_0402_1005Metric
C183, C184: Murata GRM1555C1H220JA01D; C_0402_1005Metric
C188, C192, C193: TDK C1608X7R1C105K080AC; C_0603_1608Metric
C189: Murata GRM188R60J106ME47D; C_0603_1608Metric
D4, D5: Littelfuse SESD0402X1UN-0020-090; D_0402_1005Metric
J8, J9: GCT RFPC-SMA31-FN-175-A; RFPC-SMA31-FN-175-A
L14, L15, L16, L17: LQW2BAS22NG00L; L_0805_2012Metric
L18, L21: LQW2BASR22G00L; L_0805_2012Metric
L19, L22: LQW2BAS47NG00L; L_0805_2012Metric
L20: LQW2UASR56F00L; L_1008_2520Metric
L23: LQW2BASR33G00L; L_0805_2012Metric
L24: LQW15AN47NG80D; L_0402_1005Metric
L25, L26: LQW15AN12NG80D; L_0402_1005Metric
L27: Murata LQW15AN56NG00D; L_0402_1005Metric
R147: RC0402FR-0793R1L; R_0402_1005Metric
R148, R149: RC0402FR-0782RL; R_0402_1005Metric
R150, R151, R155, R159, R160, R162, R163, R164: Yageo RC0402FR-0710KL; R_0402_1005Metric
R152: RTT023R00FTH; R_0402_1005Metric
R153, R154: Yageo RC0402JR-070RL; R_0402_1005Metric
R156, R161, R165: Yageo RC0402FR-07100KL; R_0402_1005Metric
R157, R158: UNI-ROYAL 0402WGF2201TCE; R_0402_1005Metric
U52, U58: HMC544AETR; SOT-23-6
U53: PGA-103+; SOT-89-3
U54: SI5351A-B-GTR; MSOP-10_3x3mm_P0.5mm
U55: LT5560EDD#TRPBF; DFN-8-1EP_3x3mm_P0.65mm_EP1.55x2.4mm
U56: WBC1-1TLC
U57: WBC16-1TLC
U59: 74LVC2G14GV,125; SC-74-6_1.55x2.9mm_P0.95mm
U60, U65: Texas Instruments TPS22919DCKR; SOT-363_SC-70-6
U61: Si4732-A10-GSR; SOIC-16_3.9x9.9mm_P1.27mm
U62: Seiko Epson Q13FC13500005; FC-135-Q13FC13500005
U63: Texas Instruments SN74LVC2G66DCUR; VSSOP-8_2.3x2mm_P0.5mm
U64: SN74LVC1G07DCKR; Texas_R-PDSO-G5_DCK-5
U66: Texas Instruments TPS3839K33DBZR; SOT-23
Y3: 3225-27.00-10-10-10/A; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/RF_01_USB_PD_CHARGE/POWER_GROUND: C155.2 (END_2), C156.2 (END_2), C157.2 (END_2), C158.2 (END_2), C159.2 (END_2), C160.2 (END_2), C166.2 (END_2), C167.2 (END_2), C170.2 (END_2), C171.2 (END_2), C172.2 (END_2), C174.2 (END_2), C175.2 (END_2), C176.2 (END_2), C177.2 (END_2), C178.2 (END_2), C179.2 (END_2), C183.2 (END_2), C184.2 (END_2), C186.2 (END_2), C187.2 (END_2), C188.2 (END_2), C189.2 (END_2), C190.2 (END_2), C191.2 (END_2), D4.2 (A), D5.2 (A), J8.2 (GROUND_TOP_LEFT), J8.3 (GROUND_TOP_RIGHT), J8.4 (GROUND_BOTTOM_LEFT), J8.5 (GROUND_BOTTOM_RIGHT), J9.2 (GROUND_TOP_LEFT), J9.3 (GROUND_TOP_RIGHT), J9.4 (GROUND_BOTTOM_LEFT), J9.5 (GROUND_BOTTOM_RIGHT), L14.2 (END_2), L15.2 (END_2), L16.2 (END_2), L17.2 (END_2), R148.2 (END_2), R149.2 (END_2), R152.2 (END_2), R155.2 (END_2), R156.2 (END_2), R160.2 (END_2), R161.2 (END_2), R162.2 (END_2), U52.2 (GND), U53.2 (GND_1/GND_2), U54.8 (GND), U55.1 (LO_N), U55.9 (EP_GND), U56.4 (PRI_A), U57.6 (PRI_B), U58.2 (GND), U59.2 (GND), U59.3 (2A), U60.2 (GND), U61.7 (RFGND), U61.15 (GND), U63.4 (GND), U64.3 (GND), U65.2 (GND), U66.1 (GND), Y3.2 (CASE_GND_1), Y3.4 (CASE_GND_2); also elsewhere on the board
/RF_02_PACK_SAFETY_AON/3V3_MAIN: C177.1 (END_1), C179.1 (END_1), C186.1 (END_1), C188.1 (END_1), R159.1 (END_1), U60.1 (IN), U63.8 (VCC), U65.1 (IN); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/3V3_AIR_SWITCHED: C166.1 (END_1), C167.1 (END_1), C171.1 (END_1), C172.1 (END_1), C174.1 (END_1), C175.1 (END_1), C178.1 (END_1), L23.1 (END_1), R150.1 (END_1), R151.1 (END_1), U54.1 (VDD), U54.7 (VDDO), U55.7 (VCC), U60.5 (QOD), U60.6 (VOUT)
/RF_21_BROADCAST_AIRBAND_RX/3V3_RECEIVER_SWITCHED: C176.1 (END_1), C187.1 (END_1), C189.1 (END_1), C190.1 (END_1), C191.1 (END_1), R157.1 (END_1), R158.1 (END_1), U59.5 (VCC), U61.14 (VDD), U64.5 (VCC), U65.5 (QOD), U65.6 (VOUT), U66.3 (VDD)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_IN_RF: L18.1 (END_1), U52.1 (RF2)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_N1: C155.1 (END_1), C156.1 (END_1), C157.1 (END_1), C161.2 (END_2), L14.1 (END_1), L15.1 (END_1), L20.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_N2: C158.1 (END_1), C159.1 (END_1), C160.1 (END_1), C162.2 (END_2), L16.1 (END_1), L17.1 (END_1), L21.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_OUT_RF: C163.2 (END_2), C165.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_S1_LC: C161.1 (END_1), L19.2 (END_2)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_S1_L_MID: L18.2 (END_2), L19.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_S2_LC: C162.1 (END_1), L20.2 (END_2)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_S3_LC: C163.1 (END_1), L22.2 (END_2)
/RF_21_BROADCAST_AIRBAND_RX/AIR_BPF_S3_L_MID: L21.2 (END_2), L22.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_CONVERTED_RAW_RF: C181.1 (END_1), U57.4 (PRI_A)
/RF_21_BROADCAST_AIRBAND_RX/AIR_CONVERTED_RF: C181.2 (END_2), U58.1 (RF2)
/RF_21_BROADCAST_AIRBAND_RX/AIR_DIRECT_RAW_RF: C164.1 (END_1), U52.3 (RF1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_DIRECT_RF: C164.2 (END_2), U58.3 (RF1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_LNA_IN_RF: C165.2 (END_2), U53.1 (RF_IN)
/RF_21_BROADCAST_AIRBAND_RX/AIR_LNA_OUT_BIASED: C168.1 (END_1), L23.2 (END_2), U53.3 (RF_OUT_DC_IN)
/RF_21_BROADCAST_AIRBAND_RX/AIR_LO_AC: C169.2 (END_2), L24.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_LO_CLK_RAW: R147.1 (END_1), R148.1 (END_1), U54.10 (CLK0)
/RF_21_BROADCAST_AIRBAND_RX/AIR_LO_I2C_SCL: R150.2 (END_2), U54.4 (SCL); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/AIR_LO_I2C_SDA: R151.2 (END_2), U54.5 (SDA); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/AIR_LO_MATCHED: C170.1 (END_1), L24.2 (END_2), U55.8 (LO_P)
/RF_21_BROADCAST_AIRBAND_RX/AIR_LO_PAD: C169.1 (END_1), R147.2 (END_2), R149.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_LO_XA: U54.2 (XA), Y3.1 (X1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_LO_XB: U54.3 (XB), Y3.3 (X2)
/RF_21_BROADCAST_AIRBAND_RX/AIR_MIXER_IN_N: C173.2 (END_2), L25.2 (END_2), U55.4 (IN_N)
/RF_21_BROADCAST_AIRBAND_RX/AIR_MIXER_IN_P: C173.1 (END_1), L26.2 (END_2), U55.3 (IN_P)
/RF_21_BROADCAST_AIRBAND_RX/AIR_MIXER_OUT_N: R153.1 (END_1), U55.5 (OUT_N)
/RF_21_BROADCAST_AIRBAND_RX/AIR_MIXER_OUT_P: R154.1 (END_1), U55.6 (OUT_P)
/RF_21_BROADCAST_AIRBAND_RX/AIR_RX_EN: R155.1 (END_1), U55.2 (EN), U60.3 (ON); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/AIR_RX_MODE: R156.1 (END_1), U52.6 (A), U58.6 (A), U59.1 (1A); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/AIR_RX_MODE_N: U52.4 (B), U58.4 (B), U59.6 (1Y)
/RF_21_BROADCAST_AIRBAND_RX/AIR_RX_SELECTED_RF: C180.2 (END_2), L27.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/AIR_SELECTOR_RFC: C180.1 (END_1), U58.5 (RFC)
/RF_21_BROADCAST_AIRBAND_RX/AIR_T1_PRI: C168.2 (END_2), U56.6 (PRI_B)
/RF_21_BROADCAST_AIRBAND_RX/AIR_T1_SEC_CT: R152.1 (END_1), U56.2 (SEC_CT)
/RF_21_BROADCAST_AIRBAND_RX/AIR_T1_SEC_N: L25.1 (END_1), U56.3 (SEC_B)
/RF_21_BROADCAST_AIRBAND_RX/AIR_T1_SEC_P: L26.1 (END_1), U56.1 (SEC_A)
/RF_21_BROADCAST_AIRBAND_RX/AIR_T2_SEC_A: R154.2 (END_2), U57.1 (SEC_A)
/RF_21_BROADCAST_AIRBAND_RX/AIR_T2_SEC_B: R153.2 (END_2), U57.3 (SEC_B)
/RF_21_BROADCAST_AIRBAND_RX/RX_AMI_RF: C182.2 (END_2), U61.8 (AMI)
/RF_21_BROADCAST_AIRBAND_RX/RX_AMLW_BOUNDARY_RF: C182.1 (END_1), D4.1 (K), J8.1 (RF)
/RF_21_BROADCAST_AIRBAND_RX/RX_AUDIO_L: C192.1 (END_1), U61.1 (LOUT_DFS)
/RF_21_BROADCAST_AIRBAND_RX/RX_AUDIO_L_AC: C192.2 (END_2), R163.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/RX_AUDIO_R: C193.1 (END_1), U61.16 (ROUT_DOUT)
/RF_21_BROADCAST_AIRBAND_RX/RX_AUDIO_R_AC: C193.2 (END_2), R164.1 (END_1)
/RF_21_BROADCAST_AIRBAND_RX/RX_DOMAIN_EN: R160.1 (END_1), U65.3 (ON); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/RX_FMI_RF: C185.2 (END_2), U61.6 (FMI)
/RF_21_BROADCAST_AIRBAND_RX/RX_FMSW_BOUNDARY_RF: D5.1 (K), J9.1 (RF), U52.5 (RFC)
/RF_21_BROADCAST_AIRBAND_RX/RX_FMSW_MATCHED_RF: C185.1 (END_1), L27.2 (END_2)
/RF_21_BROADCAST_AIRBAND_RX/RX_I2C_SCL: R157.2 (END_2), U61.11 (SCLK), U63.6 (2B)
/RF_21_BROADCAST_AIRBAND_RX/RX_I2C_SDA: R158.2 (END_2), U61.12 (SDIO), U63.2 (1B)
/RF_21_BROADCAST_AIRBAND_RX/RX_RST_N: R161.1 (END_1), U61.9 (RST), U63.3 (2C), U63.7 (1C), U66.2 (RESET_N)
/RF_21_BROADCAST_AIRBAND_RX/RX_SENB_LOW: R162.1 (END_1), U61.10 (SENB)
/RF_21_BROADCAST_AIRBAND_RX/RX_SI4732_MONO: R163.2 (END_2), R164.2 (END_2), R165.1 (END_1); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/RX_STATUS_LOCAL_N: U61.3 (GPO2_INTB), U64.2 (A)
/RF_21_BROADCAST_AIRBAND_RX/RX_STATUS_N: R159.2 (END_2), U64.4 (Y); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/RX_XTAL_GPO3: C183.1 (END_1), U61.2 (GPO3_DCLK), U62.2 (X2)
/RF_21_BROADCAST_AIRBAND_RX/RX_XTAL_RCLK: C184.1 (END_1), U61.13 (RCLK), U62.1 (X1)
/RF_22_AUDIO_CODEC_IO/AUDIO_VMID_MAIN: R165.2 (END_2); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/REAR_I2C_SCL: U63.5 (2A); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/REAR_I2C_SDA: U63.1 (1A); also elsewhere on the board

Schematic: RF_22_AUDIO_CODEC_IO.kicad_sch, Leshy2 R2 — rear-local codec, microphone, speaker and CTIA …

Parts:
C194, C199, C200, C201, C202, C203, C208, C210, C211, C212, C213, C214, C215, C216, C219, C220, C228, C229: Yageo CC0402KRX7R9BB104; C_0402_1005Metric
C195, C196, C197, C198, C204, C205, C206, C207, C209, C217, C221, C223, C231, C234, C235, C236, C239: TDK C1608X7R1C105K080AC; C_0603_1608Metric
C218, C230, C232, C233: Murata GRM188R60J106ME47D; C_0603_1608Metric
C222: Murata GRM155R71H103KA88D; C_0402_1005Metric
C224, C225, C226, C227: Murata GRM21BR60J226ME39L; C_0805_2012Metric
C237, C238: Murata GRM1555C1H221JA01D; C_0402_1005Metric
L28, L29, L30, L31: Murata BLM18PG181SN1D; L_0603_1608Metric
LS1: PUI Audio AS02404PO; Speaker-Wire-Termination-2P
MK1: Same Sky CMEJ-0413-42-SMT-TR; CMEJ-0413-42-SMT-TR
R166, R171, R173, R174, R175, R176, R177, R182, R185, R191, R200, R207, R211: Yageo RC0402FR-0710KL; R_0402_1005Metric
R167, R168, R169, R170, R178, R179, R186, R192, R193, R194, R195, R196, R197, R198, R199, R202, R204, R210: Yageo RC0402FR-07100KL; R_0402_1005Metric
R172, R180, R181: Yageo RC0402JR-070RL; R_0402_1005Metric
R183, R184, R187, R201, R206: UNI-ROYAL 0402WGF2201TCE; R_0402_1005Metric
R188: UNI-ROYAL 0402WGF1603TCE; R_0402_1005Metric
R189, R190: Panasonic ERJ-2RKF22R0X; R_0402_1005Metric
R203, R205: Yageo RC0402FR-07220RL; R_0402_1005Metric
R208, R209: Yageo RC0402FR-0747KL; R_0402_1005Metric
U67: TLV9061IDBVR; SOT-23-5
U68, U72, U85: Texas Instruments TS5A63157DCKR; SOT-363_SC-70-6
U69: Texas Instruments SN74LVC1G3157DBVR; SOT-23-6
U70: Texas Instruments SN74LVC2G08DCUR; VSSOP-8_2.3x2mm_P0.5mm
U71: Texas Instruments TMUX1136DGSR; TSSOP-10_3x3mm_P0.5mm
U73: Everest Semiconductor ES8311; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm
U74: Texas Instruments SN74LVC2G66DCUR; VSSOP-8_2.3x2mm_P0.5mm
U75, U77, U78, U79: Texas Instruments SN74LVC1G126DCKR; Texas_R-PDSO-G5_DCK-5
U76: SN74LVC1G08DCKR; Texas_R-PDSO-G5_DCK-5
U80: Texas Instruments TPS22919DCKR; SOT-363_SC-70-6
U81: Texas Instruments TPS3839K33DBZR; SOT-23
U82: Texas Instruments TPD4E05U06DQAR; USON-10_2.5x1.0mm_P0.5mm
U83: Same Sky SJ-43515TS-SMT-TR; SJ-43515TS-SMT-TR
U84: TCA9534APWR; TSSOP-16_4.4x5mm_P0.65mm
U86: Diodes Incorporated PAM8302AAYCR; PAM8302AAYCR-UDFN3030-8E

Connections:
/RF_01_USB_PD_CHARGE/POWER_GROUND: C211.2 (END_2), C212.2 (END_2), C213.2 (END_2), C214.2 (END_2), C215.2 (END_2), C216.2 (END_2), C217.2 (END_2), C233.2 (END_2), C237.2 (END_2), C238.2 (END_2), R172.1 (END_1), R185.2 (END_2), U74.4 (GND), U75.3 (GND), U76.3 (GND), U77.3 (GND), U78.3 (GND), U79.3 (GND), U80.2 (GND), U82.3 (GND_3), U82.8 (GND_8), U84.2 (A1), U84.3 (A2); also elsewhere on the board
/RF_02_PACK_SAFETY_AON/3V3_MAIN: C199.1 (END_1), C200.1 (END_1), C201.1 (END_1), C202.1 (END_1), C203.1 (END_1), C211.1 (END_1), C212.1 (END_1), C213.1 (END_1), C214.1 (END_1), C215.1 (END_1), C216.1 (END_1), C217.1 (END_1), C228.1 (END_1), C229.1 (END_1), C233.1 (END_1), C234.1 (END_1), R179.1 (END_1), R191.1 (END_1), R202.1 (END_1), R203.1 (END_1), R205.1 (END_1), U68.5 (VCC), U69.5 (VCC), U70.8 (VCC), U71.8 (VDD), U72.5 (VCC), U74.8 (VCC), U75.5 (VCC), U76.5 (VCC), U77.5 (VCC), U78.5 (VCC), U79.5 (VCC), U80.1 (IN), U84.1 (A0), U84.16 (VCC), U85.5 (VCC), U86.6 (VDD); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/AUDIO_BCLK: U75.2 (A); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/AUDIO_DIN: U77.4 (Y); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/AUDIO_DOUT: U78.2 (A); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/AUDIO_WS: U79.2 (A); also elsewhere on the board
/RF_20_CC1101_VOICE_TX/AUDIO_GROUND: C194.2 (END_2), C196.2 (END_2), C199.2 (END_2), C200.2 (END_2), C201.2 (END_2), C202.2 (END_2), C203.2 (END_2), C204.2 (END_2), C205.1 (END_1), C207.2 (END_2), C208.2 (END_2), C209.2 (END_2), C210.2 (END_2), C218.2 (END_2), C219.2 (END_2), C220.2 (END_2), C222.2 (END_2), C223.2 (END_2), C228.2 (END_2), C229.2 (END_2), C230.2 (END_2), C232.2 (END_2), C234.2 (END_2), MK1.2 (GND_MINUS), R166.2 (END_2), R167.2 (END_2), R171.2 (END_2), R172.2 (END_2), R173.2 (END_2), R174.2 (END_2), R175.2 (END_2), R176.2 (END_2), R177.2 (END_2), R178.2 (END_2), R186.2 (END_2), R192.2 (END_2), R193.2 (END_2), R194.2 (END_2), R195.2 (END_2), R196.2 (END_2), R197.2 (END_2), R198.2 (END_2), R199.2 (END_2), R207.2 (END_2), U67.2 (V_MINUS), U68.2 (GND), U69.2 (GND), U70.4 (GND), U71.3 (GND), U72.2 (GND), U73.5 (DGND), U73.10 (AGND), U73.21 (EPAD), U81.1 (GND), U83.4 (RING2), U84.8 (GND), U85.2 (GND), U86.7 (GND); also elsewhere on the board
/RF_20_CC1101_VOICE_TX/RX_VOICE_AFOUT_SELECTED: C239.1 (END_1); also elsewhere on the board
/RF_20_CC1101_VOICE_TX/VOICE_MIC_SELECTED_MAIN: U72.4 (COM); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/RX_SI4732_MONO: U69.3 (B1); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/3V3_CODEC_SWITCHED: C194.1 (END_1), C218.1 (END_1), C219.1 (END_1), C220.1 (END_1), L28.1 (END_1), L29.1 (END_1), R168.1 (END_1), R182.1 (END_1), R183.1 (END_1), R184.1 (END_1), U67.5 (V_PLUS), U73.3 (PVDD), U80.5 (QOD), U80.6 (VOUT), U81.3 (VDD)
/RF_22_AUDIO_CODEC_IO/AUDIO_ARM: R166.1 (END_1), U70.2 (1B), U70.6 (2B), U76.2 (B); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/AUDIO_CAPTURE_MIC_SEL: R171.1 (END_1), U68.6 (IN); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/AUDIO_SPK_CODEC_REQ: R174.1 (END_1), U70.1 (1A); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/AUDIO_SPK_SEL_SAFE: R175.1 (END_1), U70.7 (1Y), U71.1 (SEL1), U71.5 (SEL2)
/RF_22_AUDIO_CODEC_IO/AUDIO_TX_CODEC_REQ: R176.1 (END_1), U70.5 (2A); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/AUDIO_TX_SEL_SAFE: R177.1 (END_1), U70.3 (2Y), U72.6 (IN)
/RF_22_AUDIO_CODEC_IO/AUDIO_VMID_MAIN: C204.1 (END_1), R169.2 (END_2), R170.2 (END_2), R178.1 (END_1), R179.2 (END_2), R187.2 (END_2), R204.2 (END_2), R210.2 (END_2), U71.7 (S2B); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/CAPTURE_MIC_BIASED: C197.2 (END_2), R169.1 (END_1), U68.1 (NO)
/RF_22_AUDIO_CODEC_IO/CAPTURE_RX_BIASED: C198.2 (END_2), R170.1 (END_1), U68.3 (NC)
/RF_22_AUDIO_CODEC_IO/CAPTURE_SELECTED: C195.1 (END_1), U68.4 (COM)
/RF_22_AUDIO_CODEC_IO/CODEC_ADCVREF: C207.1 (END_1), U73.15 (ADCVREF)
/RF_22_AUDIO_CODEC_IO/CODEC_ADC_IN_N: R180.2 (END_2), U73.17 (MIC1N)
/RF_22_AUDIO_CODEC_IO/CODEC_ADC_IN_P: R181.2 (END_2), U73.18 (MIC1P)
/RF_22_AUDIO_CODEC_IO/CODEC_ADC_N_AC: C205.2 (END_2), R180.1 (END_1)
/RF_22_AUDIO_CODEC_IO/CODEC_ADC_P_AC: C206.2 (END_2), R181.1 (END_1)
/RF_22_AUDIO_CODEC_IO/CODEC_AVDD: C208.1 (END_1), L28.2 (END_2), U73.11 (AVDD)
/RF_22_AUDIO_CODEC_IO/CODEC_CAPTURE_BUFFER_FB: C206.1 (END_1), U67.1 (OUT), U67.4 (IN_MINUS)
/RF_22_AUDIO_CODEC_IO/CODEC_CAPTURE_VMID: C195.2 (END_2), C196.1 (END_1), R167.1 (END_1), R168.2 (END_2), U67.3 (IN_PLUS)
/RF_22_AUDIO_CODEC_IO/CODEC_DACVREF: C209.1 (END_1), U73.14 (DACVREF)
/RF_22_AUDIO_CODEC_IO/CODEC_DIN_READY: U76.4 (Y), U77.1 (OE)
/RF_22_AUDIO_CODEC_IO/CODEC_DVDD: C210.1 (END_1), L29.2 (END_2), U73.4 (DVDD)
/RF_22_AUDIO_CODEC_IO/CODEC_HP_L_RAW: C221.1 (END_1), C224.1 (END_1), C225.1 (END_1), U71.2 (S1A), U73.12 (OUTP)
/RF_22_AUDIO_CODEC_IO/CODEC_HP_R_RAW: C226.1 (END_1), C227.1 (END_1), U71.4 (S2A), U73.13 (OUTN)
/RF_22_AUDIO_CODEC_IO/CODEC_I2C_ADDR_0X19: R182.2 (END_2), U73.20 (CE)
/RF_22_AUDIO_CODEC_IO/CODEC_I2C_SCL: R183.2 (END_2), U73.1 (CCLK), U74.6 (2B)
/RF_22_AUDIO_CODEC_IO/CODEC_I2C_SDA: R184.2 (END_2), U73.19 (CDATA), U74.2 (1B)
/RF_22_AUDIO_CODEC_IO/CODEC_I2S_BCLK: U73.6 (SCLK), U75.4 (Y)
/RF_22_AUDIO_CODEC_IO/CODEC_I2S_DIN_LOCAL: U73.7 (ASDOUT), U77.2 (A)
/RF_22_AUDIO_CODEC_IO/CODEC_I2S_DOUT: U73.9 (DSDIN), U78.4 (Y)
/RF_22_AUDIO_CODEC_IO/CODEC_I2S_WS: U73.8 (LRCK), U79.4 (Y)
/RF_22_AUDIO_CODEC_IO/CODEC_PWR_EN: R185.1 (END_1), U80.3 (ON); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/CODEC_READY: R186.1 (END_1), U74.3 (2C), U74.7 (1C), U75.1 (OE), U76.1 (A), U78.1 (OE), U79.1 (OE), U81.2 (RESET_N)
/RF_22_AUDIO_CODEC_IO/CODEC_TX_AC: C221.2 (END_2), R188.1 (END_1)
/RF_22_AUDIO_CODEC_IO/CODEC_VMID: C223.1 (END_1), U73.16 (VMID)
/RF_22_AUDIO_CODEC_IO/HEADPHONE_LEFT_TIP: R189.2 (END_2), R191.2 (END_2), U82.1 (D1_PLUS), U83.2 (TIP)
/RF_22_AUDIO_CODEC_IO/HEADPHONE_L_AC: C224.2 (END_2), C225.2 (END_2), R189.1 (END_1)
/RF_22_AUDIO_CODEC_IO/HEADPHONE_RIGHT_RING1: R190.2 (END_2), U82.2 (D1_MINUS), U83.3 (RING1)
/RF_22_AUDIO_CODEC_IO/HEADPHONE_R_AC: C226.2 (END_2), C227.2 (END_2), R190.1 (END_1)
/RF_22_AUDIO_CODEC_IO/HEADSET_ABSENT: R192.1 (END_1), R200.2 (END_2); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/HEADSET_INTERNAL_MIC_SEL: R202.2 (END_2), U84.4 (P0), U85.6 (IN)
/RF_22_AUDIO_CODEC_IO/HEADSET_IO_SPARE_P1: R193.1 (END_1), U84.5 (P1)
/RF_22_AUDIO_CODEC_IO/HEADSET_IO_SPARE_P2: R194.1 (END_1), U84.6 (P2)
/RF_22_AUDIO_CODEC_IO/HEADSET_IO_SPARE_P3: R195.1 (END_1), U84.7 (P3)
/RF_22_AUDIO_CODEC_IO/HEADSET_IO_SPARE_P4: R196.1 (END_1), U84.9 (P4)
/RF_22_AUDIO_CODEC_IO/HEADSET_IO_SPARE_P5: R197.1 (END_1), U84.10 (P5)
/RF_22_AUDIO_CODEC_IO/HEADSET_IO_SPARE_P6: R198.1 (END_1), U84.11 (P6)
/RF_22_AUDIO_CODEC_IO/HEADSET_IO_SPARE_P7: R199.1 (END_1), U84.12 (P7)
/RF_22_AUDIO_CODEC_IO/HEADSET_MIC_BIAS_FILTERED: C230.1 (END_1), R201.1 (END_1), R203.2 (END_2)
/RF_22_AUDIO_CODEC_IO/HEADSET_MIC_RAW: R201.2 (END_2), U82.4 (D2_PLUS), U83.1 (SLEEVE), U85.3 (NC)
/RF_22_AUDIO_CODEC_IO/HEADSET_SWITCH_STATE: R200.1 (END_1), U83.5 (TIP_SWITCH)
/RF_22_AUDIO_CODEC_IO/MIC_BIAS_FILTERED: C232.1 (END_1), R205.2 (END_2), R206.1 (END_1)
/RF_22_AUDIO_CODEC_IO/MIC_RAW: MK1.1 (OUT_PLUS), R206.2 (END_2), U85.1 (NO)
/RF_22_AUDIO_CODEC_IO/MIC_SELECTED_RAW: C197.1 (END_1), C231.1 (END_1), U85.4 (COM)
/RF_22_AUDIO_CODEC_IO/PAM_AUDIO_IN_N: R208.2 (END_2), U86.4 (IN_MINUS)
/RF_22_AUDIO_CODEC_IO/PAM_AUDIO_IN_P: R209.2 (END_2), U86.3 (IN_PLUS)
/RF_22_AUDIO_CODEC_IO/PAM_INPUT_N_AC: C235.2 (END_2), R208.1 (END_1)
/RF_22_AUDIO_CODEC_IO/PAM_INPUT_P_AC: C236.2 (END_2), R209.1 (END_1)
/RF_22_AUDIO_CODEC_IO/REAR_I2C_SCL: U74.5 (2A), U84.14 (SCL); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/REAR_I2C_SDA: U74.1 (1A), U84.15 (SDA); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/RX_AUDIO_SELECTED: C198.1 (END_1), U69.4 (A_COM), U71.9 (S1B)
/RF_22_AUDIO_CODEC_IO/RX_AUDIO_SOURCE_SEL: R173.1 (END_1), U69.6 (S); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/RX_VOICE_AFOUT_AC: C239.2 (END_2), R211.1 (END_1)
/RF_22_AUDIO_CODEC_IO/RX_VOICE_AFOUT_BIASED: R210.1 (END_1), R211.2 (END_2), U69.1 (B2)
/RF_22_AUDIO_CODEC_IO/SPEAKER_AMP_EN: R207.1 (END_1), U86.1 (SD); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/SPEAKER_BTL_N: C237.1 (END_1), L30.2 (END_2), LS1.- (MINUS)
/RF_22_AUDIO_CODEC_IO/SPEAKER_BTL_N_RAW: L30.1 (END_1), U86.8 (VO_MINUS)
/RF_22_AUDIO_CODEC_IO/SPEAKER_BTL_P: C238.1 (END_1), L31.2 (END_2), LS1.+ (PLUS)
/RF_22_AUDIO_CODEC_IO/SPEAKER_BTL_P_RAW: L31.1 (END_1), U86.5 (VO_PLUS)
/RF_22_AUDIO_CODEC_IO/SPEAKER_SELECTED_N: C235.1 (END_1), U71.6 (D2)
/RF_22_AUDIO_CODEC_IO/SPEAKER_SELECTED_P: C236.1 (END_1), U71.10 (D1)
/RF_22_AUDIO_CODEC_IO/VOICE_CODEC_INJECT: C222.1 (END_1), R187.1 (END_1), R188.2 (END_2), U72.1 (NO)
/RF_22_AUDIO_CODEC_IO/VOICE_ELECTRET_DEFAULT: C231.2 (END_2), R204.1 (END_1), U72.3 (NC)
/RF_50_TX_SAFETY_EVIDENCE/RF_SLOW_IO_INT_N: U84.13 (INT_N); also elsewhere on the board

Schematic: RF_30_U214_U219_M5_EXT.kicad_sch, Leshy2 R2 — mutually exclusive U214/U219 Cap profiles and p…

Parts:
C240, C241, C242, C243, C244, C246, C248, C249, C254, C255, C256: Yageo CC0402KRX7R9BB104; C_0402_1005Metric
C245, C247, C257: Murata GRM155R71H103KA88D; C_0402_1005Metric
C250: Murata GRM155R71H472KA01D; C_0402_1005Metric
C251, C253: Murata GRM21BR71E225KE11L; C_0805_2012Metric
C252: Murata GRM188R71E224KA88D; C_0603_1608Metric
J10: Samtec HLE-107-02-G-DV-PE-LC; Samtec_HLE-107-02-xx-DV-PE-LC_2x07_P2.54mm_Horizontal
J11: 1125R-SMT-4P
L32: LESHY2-NFC-PICKUP-LOOP-R2; NFC_Pickup_Loop_R2
R212, R213: UNI-ROYAL 0402WGF2201TCE; R_0402_1005Metric
R214, R223, R238, R240, R241: Yageo RC0402FR-0710KL; R_0402_1005Metric
R215, R216, R217, R218, R219, R220, R221, R222: Panasonic ERJ-2RKF22R0X; R_0402_1005Metric
R224, R242: Yageo RC0402FR-07220KL; R_0402_1005Metric
R225, R243: Yageo RC0402FR-07110KL; R_0402_1005Metric
R226, R232: 0402WGF1003TCE; R_0402_1005Metric
R227: 0402WGF1004TCE; R_0402_1005Metric
R228, R229: 0402WGF1001TCE; R_0402_1005Metric
R230, R231, R233, R234: 0402WGF1002TCE; R_0402_1005Metric
R235: Yageo RC0603FR-071KL; R_0603_1608Metric
R236: Yageo RC0402FR-0747KL; R_0402_1005Metric
R237: Yageo RC0402FR-07169KL; R_0402_1005Metric
R239: Yageo RC0402FR-071K82L; R_0402_1005Metric
U87, U88, U89, U101: Texas Instruments TPD4E05U06DQAR; USON-10_2.5x1.0mm_P0.5mm
U90, U91, U93: Nexperia 74LVC126APW,118; TSSOP-14_4.4x5mm_P0.65mm
U92: TCA4307DGKR; VSSOP-8_3x3mm_P0.65mm
U94, U103: TPS3808G33DBVR; SOT-23-6
U95, U96: BAT54S,215; SOT-23
U97: LMV331IDBVR; SOT-23-5
U98: Texas Instruments SN74LVC1G06DCKR; Texas_R-PDSO-G5_DCK-5
U99: SN74CBTLV1G125DCKR; Texas_R-PDSO-G5_DCK-5
U100: Texas Instruments TPS259470LRPWR; TI-RPW0010A-VQFN-HR-10
U102: Texas Instruments TXS0102DCUR; VSSOP-8_2.3x2mm_P0.5mm

Connections:
/RF_01_USB_PD_CHARGE/AON_SAFE_3V3: C244.1 (END_1), C246.1 (END_1), C248.1 (END_1), C256.1 (END_1), R230.1 (END_1), R232.1 (END_1), R234.1 (END_1), U94.6 (VDD), U97.5 (VCC), U98.5 (VCC), U103.6 (VDD); also elsewhere on the board
/RF_01_USB_PD_CHARGE/POWER_GROUND: C240.2 (END_2), C241.2 (END_2), C242.2 (END_2), C243.2 (END_2), C244.2 (END_2), C245.2 (END_2), C246.2 (END_2), C247.2 (END_2), C248.2 (END_2), C249.2 (END_2), C250.2 (END_2), C251.2 (END_2), C252.2 (END_2), C253.2 (END_2), C254.2 (END_2), C255.2 (END_2), C256.2 (END_2), C257.2 (END_2), J10.6 (PIN_6), J11.1 (GND), R214.2 (END_2), R224.2 (END_2), R226.2 (END_2), R231.2 (END_2), R233.2 (END_2), R235.2 (END_2), R236.2 (END_2), R238.2 (END_2), R239.2 (END_2), R240.2 (END_2), R242.2 (END_2), U87.3 (GND_3), U87.8 (GND_8), U88.3 (GND_3), U88.8 (GND_8), U89.3 (GND_3), U89.8 (GND_8), U90.7 (GND), U91.4 (2OE), U91.5 (2A), U91.7 (GND), U91.9 (3A), U91.10 (3OE), U91.12 (4A), U91.13 (4OE), U92.4 (GND), U93.1 (1OE), U93.2 (1A), U93.7 (GND), U94.2 (GND), U95.1 (A1), U96.1 (A1), U97.2 (GND), U98.3 (GND), U99.3 (GND), U100.8 (GND), U101.3 (GND_3), U101.8 (GND_8), U102.2 (GND), U103.2 (GND); also elsewhere on the board
/RF_02_PACK_SAFETY_AON/3V3_MAIN: C240.1 (END_1), C241.1 (END_1), C242.1 (END_1), C243.1 (END_1), C249.1 (END_1), C254.1 (END_1), C255.1 (END_1), R212.1 (END_1), R213.1 (END_1), R223.1 (END_1), R241.1 (END_1), U90.14 (VCC), U91.14 (VCC), U92.8 (VCC), U93.14 (VCC), U99.5 (VCC), U102.3 (VCCA), U102.7 (VCCB); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/5V_EXT_PREPROTECT: C251.1 (END_1), R237.1 (END_1), U100.5 (IN); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/5V_U214_PROTECTED: J10.7 (PIN_7), R225.1 (END_1); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/POWER_FAULT_N: U100.4 (FLT); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/U214_5V_EN_SAFE: U94.3 (MR_N); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/U214_5V_REQ: R214.1 (END_1); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/UNIT_5V_REQ: R238.1 (END_1); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_GNSS_RX_OR_CC_GDO0: R216.2 (END_2); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_GNSS_TX_OR_RF_SW0: U90.5 (2A); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_IRQ: R217.2 (END_2); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_PIN10_HOST: U99.4 (B); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_RESET_N_OR_POWER_EN: U90.2 (1A); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_SPI_MISO: R218.2 (END_2); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_SPI_MOSI: U90.12 (4A); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_SPI_PRIMARY_CS_N: U91.2 (1A); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/CAP_SPI_SCK: U90.9 (3A); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/M5_UNIT_SIG0: U102.5 (A1); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/M5_UNIT_SIG1: U102.4 (A2); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/5V_UNIT_PROTECTED: C253.1 (END_1), J11.2 (5V), R235.1 (END_1), R243.1 (END_1), U100.6 (OUT)
/RF_30_U214_U219_M5_EXT/CAP_I2C_SCL: R212.2 (END_2), U92.3 (SCLIN); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/CAP_I2C_SDA: R213.2 (END_2), U92.6 (SDAIN); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/EV_N9_U219_NFC: R227.1 (END_1), R230.2 (END_2), U97.4 (OUT); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/NFC_BRIDGE_AC_N: R228.2 (END_2), U96.3 (K1_A2)
/RF_30_U214_U219_M5_EXT/NFC_BRIDGE_AC_P: R229.2 (END_2), U95.3 (K1_A2)
/RF_30_U214_U219_M5_EXT/NFC_FIELD_ENV: C247.1 (END_1), R226.1 (END_1), U95.2 (K2), U96.2 (K2), U97.3 (IN_N)
/RF_30_U214_U219_M5_EXT/NFC_FIELD_THRESHOLD: R227.2 (END_2), R231.1 (END_1), R232.2 (END_2), U97.1 (IN_P)
/RF_30_U214_U219_M5_EXT/NFC_PICKUP_N: L32.2 (END_N), R228.1 (END_1)
/RF_30_U214_U219_M5_EXT/NFC_PICKUP_P: L32.1 (END_P), R229.1 (END_1)
/RF_30_U214_U219_M5_EXT/U214_5V_SENSE: R224.1 (END_1), R225.2 (END_2), U94.5 (SENSE)
/RF_30_U214_U219_M5_EXT/U214_BUSY_CONNECTOR: J10.10 (PIN_10), U88.5 (D2_MINUS), U99.2 (A)
/RF_30_U214_U219_M5_EXT/U214_GPS_RX_BUFFERED: R215.1 (END_1), U90.6 (2Y)
/RF_30_U214_U219_M5_EXT/U214_GPS_RX_CONNECTOR: J10.2 (PIN_2), R215.2 (END_2), U87.5 (D2_MINUS)
/RF_30_U214_U219_M5_EXT/U214_GPS_TX_BUFFERED: R216.1 (END_1), U93.8 (3Y)
/RF_30_U214_U219_M5_EXT/U214_GPS_TX_CONNECTOR: J10.1 (PIN_1), U89.2 (D1_MINUS), U93.9 (3A)
/RF_30_U214_U219_M5_EXT/U214_I2C_READY: U92.5 (READY); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/U214_I2C_SCL_OUT: J10.3 (PIN_3), U87.2 (D1_MINUS), U92.2 (SCLOUT)
/RF_30_U214_U219_M5_EXT/U214_I2C_SDA_OUT: J10.4 (PIN_4), U87.1 (D1_PLUS), U92.7 (SDAOUT)
/RF_30_U214_U219_M5_EXT/U214_IRQ_BUFFERED: R217.1 (END_1), U93.6 (2Y)
/RF_30_U214_U219_M5_EXT/U214_IRQ_CONNECTOR: J10.9 (PIN_9), U89.1 (D1_PLUS), U93.5 (2A)
/RF_30_U214_U219_M5_EXT/U214_MISO_BUFFERED: R218.1 (END_1), U93.11 (4Y)
/RF_30_U214_U219_M5_EXT/U214_MISO_CONNECTOR: J10.13 (PIN_13), U89.4 (D2_PLUS), U93.12 (4A)
/RF_30_U214_U219_M5_EXT/U214_MOSI_BUFFERED: R219.1 (END_1), U90.11 (4Y)
/RF_30_U214_U219_M5_EXT/U214_MOSI_CONNECTOR: J10.12 (PIN_12), R219.2 (END_2), U88.2 (D1_MINUS)
/RF_30_U214_U219_M5_EXT/U214_NSS_BUFFERED: R220.1 (END_1), U91.3 (1Y)
/RF_30_U214_U219_M5_EXT/U214_NSS_CONNECTOR: J10.14 (PIN_14), R220.2 (END_2), U88.4 (D2_PLUS)
/RF_30_U214_U219_M5_EXT/U214_PIN5_PROFILE: J10.5 (PIN_5), U89.5 (D2_MINUS); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/U214_READY: R223.2 (END_2), R233.1 (END_1), U90.1 (1OE), U90.4 (2OE), U90.10 (3OE), U90.13 (4OE), U91.1 (1OE), U92.1 (EN), U93.4 (2OE), U93.10 (3OE), U93.13 (4OE), U94.1 (RESET_N), U98.2 (A)
/RF_30_U214_U219_M5_EXT/U214_READY_DELAY: C245.1 (END_1), U94.4 (CT)
/RF_30_U214_U219_M5_EXT/U214_RST_BUFFERED: R221.1 (END_1), U90.3 (1Y)
/RF_30_U214_U219_M5_EXT/U214_RST_CONNECTOR: J10.8 (PIN_8), R221.2 (END_2), U87.4 (D2_PLUS)
/RF_30_U214_U219_M5_EXT/U214_SCK_BUFFERED: R222.1 (END_1), U90.8 (3Y)
/RF_30_U214_U219_M5_EXT/U214_SCK_CONNECTOR: J10.11 (PIN_11), R222.2 (END_2), U88.1 (D1_PLUS)
/RF_30_U214_U219_M5_EXT/U219_PIN10_OE_N: R234.2 (END_2), U98.4 (Y), U99.1 (OE_N)
/RF_30_U214_U219_M5_EXT/UNIT_5V_EN_SAFE: U100.1 (EN_UVLO), U103.3 (MR_N); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/UNIT_5V_SENSE: R242.1 (END_1), R243.2 (END_2), U103.5 (SENSE)
/RF_30_U214_U219_M5_EXT/UNIT_CONNECTOR_SIG0: J11.3 (SIG0), U101.1 (D1_PLUS), U102.8 (B1)
/RF_30_U214_U219_M5_EXT/UNIT_CONNECTOR_SIG1: J11.4 (SIG1), U101.2 (D1_MINUS), U102.1 (B2)
/RF_30_U214_U219_M5_EXT/UNIT_EFUSE_DVDT: C250.1 (END_1), U100.7 (DVDT)
/RF_30_U214_U219_M5_EXT/UNIT_EFUSE_ILM_SET: R239.1 (END_1), U100.9 (ILM)
/RF_30_U214_U219_M5_EXT/UNIT_EFUSE_ITIMER: C252.1 (END_1), U100.10 (ITIMER)
/RF_30_U214_U219_M5_EXT/UNIT_EFUSE_OVLO_SENSE: R236.1 (END_1), R237.2 (END_2), U100.2 (OVLO)
/RF_30_U214_U219_M5_EXT/UNIT_READY: R240.1 (END_1), R241.2 (END_2), U102.6 (OE), U103.1 (RESET_N); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/UNIT_READY_DELAY: C257.1 (END_1), U103.4 (CT)

Schematic: RF_31_REAR_CONTROLS.kicad_sch, Leshy2 R2 — rear power command and service-side controls

Parts:
C258, C260, C261: Yageo CC0402KRX7R9BB104; C_0402_1005Metric
C259: TDK C1608X7R1C105K080AC; C_0603_1608Metric
R244, R248: Yageo RC0402FR-0710KL; R_0402_1005Metric
R245: Yageo RC0603FR-071KL; R_0603_1608Metric
R246, R247: UNI-ROYAL 0402WGF2201TCE; R_0402_1005Metric
SW3: Alps Alpine EC11E18244AU; EC11E18244AU-ENGINEERING-PTH
SW4: OMRON B3S-1100P; B3S-1100P
U104, U105: Texas Instruments TPD4E05U06DQAR; USON-10_2.5x1.0mm_P0.5mm
U106: TCA6424ARGJR

Connections:
/RF_01_USB_PD_CHARGE/POWER_GROUND: C258.2 (END_2), C259.2 (END_2), C260.2 (END_2), C261.2 (END_2), SW3.C, SW3.D (SW2), SW4.1 (SIDE_B_2), SW4.2 (SIDE_B_1), SW4.5 (GROUND), U104.3 (GND_3), U104.8 (GND_8), U105.3 (GND_3), U105.8 (GND_8), U106.25 (GND), U106.26 (ADDR), U106.33 (EPAD); also elsewhere on the board
/RF_02_PACK_SAFETY_AON/3V3_MAIN: C259.1 (END_1), C260.1 (END_1), C261.1 (END_1), R244.1 (END_1), R246.1 (END_1), R247.1 (END_1), R248.1 (END_1), U106.27 (VCCP), U106.31 (VCCI); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/POWER_FAULT_N: U106.8 (P07); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/U214_5V_REQ: U106.17 (P20); also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/UNIT_5V_REQ: U106.6 (P05); also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/PTT_BUTTON_N: R245.2 (END_2); also elsewhere on the board
/RF_20_CC1101_VOICE_TX/CC_BAND_V1_REQ: U106.4 (P03); also elsewhere on the board
/RF_20_CC1101_VOICE_TX/CC_BAND_V2_REQ: U106.5 (P04); also elsewhere on the board
/RF_20_CC1101_VOICE_TX/VOICE_HL_RELEASE_REQ: U106.13 (P14); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/RX_DOMAIN_EN: U106.14 (P15); also elsewhere on the board
/RF_21_BROADCAST_AIRBAND_RX/RX_STATUS_N: U106.21 (P24); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/AUDIO_CAPTURE_MIC_SEL: U106.1 (P00); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/AUDIO_SPK_CODEC_REQ: U106.10 (P11); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/AUDIO_TX_CODEC_REQ: U106.11 (P12); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/CODEC_PWR_EN: U106.20 (P23); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/HEADSET_ABSENT: U106.3 (P02); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/REAR_I2C_SCL: R246.2 (END_2), U106.29 (SCL); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/REAR_I2C_SDA: R247.2 (END_2), U106.30 (SDA); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/RX_AUDIO_SOURCE_SEL: U106.24 (P27); also elsewhere on the board
/RF_22_AUDIO_CODEC_IO/SPEAKER_AMP_EN: U106.2 (P01); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/U214_I2C_READY: U106.15 (P16); also elsewhere on the board
/RF_30_U214_U219_M5_EXT/UNIT_READY: U106.23 (P26); also elsewhere on the board
/RF_31_REAR_CONTROLS/ENCODER_A: SW3.A, U104.1 (D1_PLUS); also elsewhere on the board
/RF_31_REAR_CONTROLS/ENCODER_B: SW3.B, U104.2 (D1_MINUS); also elsewhere on the board
/RF_31_REAR_CONTROLS/PTT_BUTTON_RAW_N: C258.1 (END_1), R244.2 (END_2), R245.1 (END_1), SW4.3 (SIDE_A_2), SW4.4 (SIDE_A_1), U104.4 (D2_PLUS)
/RF_31_REAR_CONTROLS/SLOW_IO_RESET_N: R248.2 (END_2), U106.28 (RESET)
/RF_31_REAR_CONTROLS/UI_ENCODER_PUSH_N: SW3.E (SW1), U105.1 (D1_PLUS); also elsewhere on the board
/RF_31_REAR_CONTROLS/VOICE_DOMAIN_REQ: U106.12 (P13); also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/FAULT_LATCH_SENSE: U106.16 (P17); also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/RF_SLOW_IO_INT_N: U106.32 (INT); also elsewhere on the board

Schematic: RF_40_INTERBOARD_M1.kicad_sch, Leshy2 R2 — rear endpoint of the exact 80-contact M1 contra…

Parts:
J12: Hirose FX8C-80S-SV5(92); Hirose_FX8-80S-SV_2x40_P0.6mm

Connections:
/RF_01_USB_PD_CHARGE/AON_SAFE_3V3: J12.17, J12.19; also elsewhere on the board
/RF_01_USB_PD_CHARGE/POWER_GROUND: J12.1, J12.3, J12.5, J12.7, J12.9, J12.11, J12.13, J12.15, J12.18, J12.20, J12.21, J12.25, J12.28, J12.31, J12.34, J12.40, J12.47, J12.54, J12.65, J12.67, J12.69, J12.71, J12.73, J12.75; also elsewhere on the board
/RF_01_USB_PD_CHARGE/S3_USB_N: J12.29; also elsewhere on the board
/RF_01_USB_PD_CHARGE/S3_USB_P: J12.30; also elsewhere on the board
/RF_02_PACK_SAFETY_AON/3V3_MAIN: J12.2, J12.4, J12.6, J12.8, J12.10, J12.12, J12.14, J12.16, J12.66, J12.68, J12.70, J12.72, J12.74, J12.76; also elsewhere on the board
/RF_02_PACK_SAFETY_AON/HUB_SAFE_I2C_SCL_MAIN: J12.33; also elsewhere on the board
/RF_02_PACK_SAFETY_AON/HUB_SAFE_I2C_SDA_MAIN: J12.32; also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/EV_N8_LORA_EXT: J12.50; also elsewhere on the board
/RF_03_MAIN_RAILS_DOMAIN_GATES/FAULT_ASSERT_N: J12.38; also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/HUB_RF_ALERT_N: J12.22; also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/HUB_RF_CS_N: J12.23; also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/HUB_RF_MISO: J12.27; also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/HUB_RF_MOSI: J12.26; also elsewhere on the board
/RF_10_RP2354_CORE_SERVICE/HUB_RF_SCK: J12.24; also elsewhere on the board
/RF_31_REAR_CONTROLS/ENCODER_A: J12.51; also elsewhere on the board
/RF_31_REAR_CONTROLS/ENCODER_B: J12.52; also elsewhere on the board
/RF_31_REAR_CONTROLS/UI_ENCODER_PUSH_N: J12.53; also elsewhere on the board
/RF_40_INTERBOARD_M1/S3_RESET_KILL_GATE: J12.36; also elsewhere on the board
/RF_40_INTERBOARD_M1/UI_ZONE_TEMP_ADC: J12.39; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/AON_SERVICE_RELEASE_REQ: J12.57; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/C5_MUX_SEL_REQUEST: J12.55; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/C5_SERVICE_OWNED: J12.58; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/C5_SERVICE_PATH_ACK: J12.56; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/EV_N0_S3: J12.41; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/EV_N1_C5: J12.42; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/EV_N2_NRF0: J12.43; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/EV_N3_NRF1: J12.44; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/EV_N4_NRF2: J12.45; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/EV_N5_CC: J12.48; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/EV_N6_VOICE: J12.49; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/EV_N7_IR: J12.46; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/FAULT_KILL: J12.35; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/HUB_AON_ALERT_N: J12.59; also elsewhere on the board
/RF_50_TX_SAFETY_EVIDENCE/RUN_PERMIT: J12.37; also elsewhere on the board
